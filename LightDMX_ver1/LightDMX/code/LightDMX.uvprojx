# Keil uVision project LightDMX.uvprojx, settings and files
target LightDMX (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IROM(0x08000000,0x00010000) IRAM(0x20000000,0x00005000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: LightDMX +hex
  c flags: Optim=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: RVDS_ARMCM3_LM3S102 USE_STDPERIPH_DRIVER STM32F10X_MD
  c include: .\Function;.\source\include;.\source\portable\MemMang;.\Task;.\
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  scatter file: .\Object\LightDMX.sct
  group main
    ./: main.c stm32f10x_it.c
  group Function
    ./Function/: RTC_BKP.c 24C02.c LightDMX.c PWM.c dmx512_rec.c serial_tracer.c IRDA.c
  group RTOS
    ./source/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
    ./source/portable/RVDS/ARM_CM3/: port.c
    ./source/portable/MemMang/: heap_4.c
  group Task
    ./Task/: Main_Task.c
software components: CMSIS:CORE 3.40.0, Device:Startup 1.0.0, Device:StdPeriph Drivers:BKP 3.5.0, Device:StdPeriph Drivers:EXTI 3.5.0, Device:StdPeriph Drivers:Flash 3.5.0, Device:StdPeriph Drivers:Framework 3.5.1, Device:StdPeriph Drivers:GPIO 3.5.0, Device:StdPeriph Drivers:I2C 3.5.0, Device:StdPeriph Drivers:PWR 3.5.0, Device:StdPeriph Drivers:RCC 3.5.0, Device:StdPeriph Drivers:RTC 3.5.0, Device:StdPeriph Drivers:TIM 3.5.0, Device:StdPeriph Drivers:USART 3.5.0
